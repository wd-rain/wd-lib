# Keil uVision project clib-demo.uvprojx, settings and files
target clib-demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: clib-demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../User/BSP;../User/APP;../User/OS;../../clib-code;../../clib-code/os/timer;../../clib-code/platform/example/STM32F407ZGT6/gpio;../../clib-code/platform/example/STM32F407ZGT6/i2c;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/BSP
    ../User/BSP/: bsp.c
    ../../clib-code/platform/example/STM32F407ZGT6/gpio/: bsp_gpio.c bsp_gpio_isr.c
    ../../clib-code/platform/example/STM32F407ZGT6/i2c/: bsp_i2c.c
  group Application/User/APP
    ../User/APP/: app.c
  group clib-code/platform
    ../../clib-code/platform/gpio/: gpio.c gpio_isr.c
    ../../clib-code/platform/isr/: isr.c
    ../../clib-code/platform/i2c/: i2c.c
  group clib-code/os
    ../../clib-code/os/timer/: timer.c
  group clib-code/tool
    ../../clib-code/tool/rb/: rb.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
